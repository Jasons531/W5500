# Keil uVision project W5500.uvprojx, settings and files
target W5500 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F207VC STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: W5500
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F207xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F2xx_HAL_Driver/Inc;../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F2xx/Include;../Drivers/CMSIS/Include;..\Src\Ethernet\W5500;..\Inc\Ethernet\Internet
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_spi.c stm32f2xx_hal_uart.c stm32f2xx_hal_rcc.c stm32f2xx_hal_gpio.c stm32f2xx_hal_flash.c stm32f2xx_hal_tim.c stm32f2xx_hal.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_dma.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma_ex.c
  group Application/MDK-ARM
    ./: startup_stm32f207xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
  group Application/User
    ../Src/: spi.c gpio.c main.c stm32f2xx_it.c stm32f2xx_hal_msp.c usart.c
  group DOC
    ../DOC/: readme.txt
  group W5500
    ../Src/Ethernet/W5500/: socket.c w5500.c w5500_conf.c
  group Internet
    ../Src/Ethernet/Internet/: dhcp.c tcp_demo.c
    ../Src/Ethernet/W5500/: utility.c
software components: CMSIS:CORE 4.1.0
